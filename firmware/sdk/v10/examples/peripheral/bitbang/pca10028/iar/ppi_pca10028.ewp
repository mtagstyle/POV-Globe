# IAR project ppi_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51
  ICCARM.CCIncludePath2: ..\..\config\ppi_pca10028; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\ppi; ..\..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\bsp; ..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51
  AARM.AUserIncludes: ..\..\config\ppi_pca10028; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\ppi; ..\..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\bsp; ..\..
  OBJCOPY.OOCOutputFile: ppi_pca10028.hex
  ILINK.IlinkOutputFile: ppi_pca10028.out
  ILINK.IlinkIcfFile: ppi_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../: main.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/uart/: retarget.c
